Commit message: reward_shaping

File: Rock-Walk/rock_walk/resources/models/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=200 200 10; visual mesh filename=mesh/plane.obj scale=1 1 1
